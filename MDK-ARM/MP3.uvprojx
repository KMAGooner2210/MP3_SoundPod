# Keil uVision project MP3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: setup
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: ..\Drivers\Peripherals;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\User;..\Lib\DFPlayer;..\Lib\PAM8403;..\Lib\Uart;..\Lib\Button;..\Lib\OLED;..\Lib\I2C;..\Lib\ILI9225
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c
    ./: FreeRTOSConfig.h
  group FreeRTOS
    ../FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Lib
    ../Lib/DFPlayer/: dfplayer.c dfplayer.h
    ../Lib/PAM8403/: pam8403.c pam8403.h
    ../Lib/Uart/: usart_dri.c usart_dri.h
    ../Lib/Button/: button.c button.h
    ../../He thong diem danh sinh vien VER 3/: ssd1306.c ssd1306.h fonts.c fonts.h i2c.c i2c.h
    ./: ili9225.c ili9225.h ili9225_fonts.c ili9225_fonts.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
